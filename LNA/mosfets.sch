v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {NMOS_MIN.sym} 80 -20 0 0 {name=M5 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 -20 0 0 {name=M6 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 -20 0 0 {name=M7 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 -20 0 0 {name=M8 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 80 80 0 0 {name=M9 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 80 0 0 {name=M10 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 80 0 0 {name=M11 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 80 0 0 {name=M12 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 80 170 0 0 {name=M13 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 170 0 0 {name=M14 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 170 0 0 {name=M29 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 170 0 0 {name=M30 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
