v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {NMOS_MIN.sym} 80 -110 0 0 {name=M1 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 -110 0 0 {name=M2 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 -110 0 0 {name=M3 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 -110 0 0 {name=M4 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 80 -20 0 0 {name=M5 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 -20 0 0 {name=M6 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 -20 0 0 {name=M7 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 -20 0 0 {name=M8 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 80 80 0 0 {name=M9 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 80 0 0 {name=M10 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 80 0 0 {name=M11 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 80 0 0 {name=M12 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 80 170 0 0 {name=M13 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 150 170 0 0 {name=M14 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 370 -110 0 0 {name=M15 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 430 -110 0 0 {name=M16 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 490 -110 0 0 {name=M17 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 550 -110 0 0 {name=M18 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 370 -20 0 0 {name=M19 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 430 -20 0 0 {name=M20 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 490 -20 0 0 {name=M21 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 550 -20 0 0 {name=M22 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 370 80 0 0 {name=M23 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 430 80 0 0 {name=M24 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 490 80 0 0 {name=M25 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 550 80 0 0 {name=M26 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 370 170 0 0 {name=M27 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 430 170 0 0 {name=M28 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 210 170 0 0 {name=M29 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 270 170 0 0 {name=M30 model=nch w=10u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 490 170 0 0 {name=M31 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 550 170 0 0 {name=M32 model=pch w=40u l=10u as=0 ps=0 ad=0 pd=0 m=1}
