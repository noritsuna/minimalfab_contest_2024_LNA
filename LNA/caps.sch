v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {CAP_MIN.sym} 150 10 0 0 {name=C3
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 210 10 0 0 {name=C4
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 30 110 0 0 {name=C5
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 90 110 0 0 {name=C6
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 150 110 0 0 {name=C7
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 210 110 0 0 {name=C8
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 30 200 0 0 {name=C9
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 90 200 0 0 {name=C10
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 150 200 0 0 {name=C11
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 210 200 0 0 {name=C12
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 30 300 0 0 {name=C13
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 90 300 0 0 {name=C14
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 150 300 0 0 {name=C15
m=1
value=0.414p
footprint=1206
device=ceramic}
C {CAP_MIN.sym} 210 300 0 0 {name=C16
m=1
value=0.414p
footprint=1206
device=ceramic}
