v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {RES_MIN.sym} 340 190 0 0 {name=R41
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 190 0 0 {name=R42
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 190 0 0 {name=R43
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 190 0 0 {name=R44
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 280 0 0 {name=R45
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 280 0 0 {name=R46
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 280 0 0 {name=R47
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 280 0 0 {name=R48
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 370 0 0 {name=R49
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 370 0 0 {name=R50
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 370 0 0 {name=R51
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 370 0 0 {name=R52
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 460 0 0 {name=R53
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 460 0 0 {name=R54
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 460 0 0 {name=R55
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 460 0 0 {name=R56
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 550 0 0 {name=R57
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 550 0 0 {name=R58
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 550 0 0 {name=R59
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 550 0 0 {name=R60
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 340 640 0 0 {name=R61
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 400 640 0 0 {name=R62
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 450 640 0 0 {name=R63
value=3.6k
footprint=1206
device=resistor
m=1}
C {RES_MIN.sym} 500 640 0 0 {name=R64
value=3.6k
footprint=1206
device=resistor
m=1}
